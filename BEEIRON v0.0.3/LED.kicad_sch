File: BEEIRON v0.0.3/LED.kicad_sch (KiCad schematic)
At the start: 8 parts

Commit message: added bakup file
Parts:
- renumbered R23 to R32, R24 to R33, R25 to R34, R26 to R35
